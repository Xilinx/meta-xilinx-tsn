PACKAGECONFIG += "tftp"
