SRC_URI += " file://changed-mac-address-and-added-packet-switching-support.patch \
	     file://0001-common_proc.tcl.patch \
"
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
