EXTRA_OECONF += "--disable-docs"
